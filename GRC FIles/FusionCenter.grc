options:
  parameters:
    generate_options: qt_gui
    id: Fusion
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: interval
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: switch
  id: variable
  parameters:
    value: '0'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: txfreq
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 1-switch
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: Test_two.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: switch
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: switch
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: thresh
  states: {}
- name: customModule_ReactiveHandoff_0_0
  id: customModule_ReactiveHandoff
  parameters:
    chan_bw: '10000000'
    delay: '0.4'
    initial_trials: '0'
    num_channels: '8'
    start_freq: '713000000'
  states: {}
- name: customModule_ReactiveHandoff_1_0
  id: customModule_ReactiveHandoff
  parameters:
    chan_bw: '25000000'
    delay: '0.4'
    initial_trials: '20'
    num_channels: '5'
    start_freq: '2412000000'
  states: {state: disabled}
- name: customModule_TDD_0_0
  id: customModule_TDD
  parameters:
    duration1: '0.8'
    duration2: '0.1'
    order: '10'
  states: {}
- name: customModule_TDD_0_0_0
  id: customModule_TDD
  parameters:
    duration1: '0.7'
    duration2: '0.2'
    order: '1'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: txfreq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50300'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50301'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50302'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50303'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50305'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_0_2
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50700'
    src_zeros: 'False'
    type: float
  states: {}
- name: network_udp_source_0_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '50304'
    src_zeros: 'False'
    type: float
  states: {}
- name: ofdmtransmit_0
  id: ofdmtransmit
  parameters:
    rolloff: '0'
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"Sensed"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '5600'
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_divide_xx_0, '0', blocks_divide_xx_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_divide_xx_0_1, '1']
- [blocks_divide_xx_0_1, '0', blocks_threshold_ff_1, '0']
- [blocks_divide_xx_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0_0, '0', ofdmtransmit_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', customModule_ReactiveHandoff_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_multiply_xx_0, '0']
- [customModule_TDD_0_0, '0', blocks_multiply_xx_0_0, '0']
- [customModule_TDD_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [network_udp_source_0, '0', blocks_add_xx_0, '0']
- [network_udp_source_0_0, '0', blocks_add_xx_0_0, '0']
- [network_udp_source_0_0_0, '0', blocks_add_xx_0, '1']
- [network_udp_source_0_0_0_0, '0', blocks_add_xx_0_0, '1']
- [network_udp_source_0_0_1, '0', blocks_add_xx_0_0, '2']
- [network_udp_source_0_0_2, '0', customModule_ReactiveHandoff_0_0, '1']
- [network_udp_source_0_1, '0', blocks_add_xx_0, '2']
- [ofdmtransmit_0, '0', blocks_multiply_xx_0_0, '1']
- [ofdmtransmit_0, '0', qtgui_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
