options:
  parameters:
    generate_options: qt_gui
    id: SDR4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '2432000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: switch
  id: variable
  parameters:
    value: '0'
  states: {}
- name: OFDMReciever_0
  id: OFDMReciever
  parameters:
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: result
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0_1_0_0
  id: blocks_file_source
  parameters:
    file: PU.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: switch
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: customModule_TDD_0_0_0_0
  id: customModule_TDD
  parameters:
    duration1: '180'
    duration2: '180'
    order: '1'
  states: {state: disabled}
- name: iio_pluto_sink_0_1_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2487000000'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.6.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.6.1
  states: {}
- name: ofdmtransmit_0_1_0_0
  id: ofdmtransmit
  parameters:
    rolloff: '0'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Full Spectrum 4"'
    type: float
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '5345'
  states: {}

connections:
- [OFDMReciever_0, '0', blocks_file_sink_0_0, '0']
- [analog_noise_source_x_1, '0', blocks_selector_0, '0']
- [blocks_file_source_0_1_0_0, '0', ofdmtransmit_0_1_0_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', iio_pluto_sink_0_1_0, '0']
- [blocks_selector_0, '0', OFDMReciever_0, '0']
- [customModule_TDD_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [iio_pluto_source_0, '0', blocks_selector_0, '1']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0_1_1_0, '0']
- [ofdmtransmit_0_1_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
