options:
  parameters:
    generate_options: qt_gui
    id: SDR1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '10'
    value: '4'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0_1_0_0_0
  id: blocks_file_source
  parameters:
    file: PU.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: customModule_EnergyDetection_1
  id: customModule_EnergyDetection
  parameters:
    Ns: '100'
  states: {}
- name: customModule_MaxEigen_0
  id: customModule_MaxEigen
  parameters:
    Ns: '100'
    Pf: '0.1'
    scaling: '1'
    smoothing: '16'
  states: {}
- name: customModule_TDD_0_0_0_0_0
  id: customModule_TDD
  parameters:
    duration1: '180'
    duration2: '180'
    order: '1'
  states: {state: disabled}
- name: iio_pluto_sink_0_1_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2487000000'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.4.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.4.1
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '50300'
    send_eof: 'False'
    type: float
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '50301'
    send_eof: 'False'
    type: float
  states: {}
- name: network_udp_sink_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '50700'
    send_eof: 'False'
    type: float
  states: {}
- name: ofdmtransmit_0_1_0_0_0
  id: ofdmtransmit
  parameters:
    rolloff: '0'
  states: {state: disabled}
- name: qtgui_sink_x_4
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '5331'
  states: {}

connections:
- [blocks_complex_to_float_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_file_source_0_1_0_0_0, '0', ofdmtransmit_0_1_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', iio_pluto_sink_0_1_0_0, '0']
- [blocks_stream_to_vector_0, '0', customModule_MaxEigen_0, '0']
- [blocks_stream_to_vector_0_0, '0', customModule_EnergyDetection_1, '0']
- [blocks_vector_to_stream_0, '0', network_udp_sink_0, '0']
- [blocks_vector_to_stream_0_0, '0', network_udp_sink_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', network_udp_sink_0_1, '0']
- [customModule_EnergyDetection_1, '0', blocks_vector_to_stream_0_2, '0']
- [customModule_MaxEigen_0, '0', blocks_vector_to_stream_0, '0']
- [customModule_MaxEigen_0, '1', blocks_vector_to_stream_0_0, '0']
- [customModule_TDD_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_4, '0']
- [ofdmtransmit_0_1_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
