options:
  parameters:
    generate_options: qt_gui
    id: last_na
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: num_in
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: num_in
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: num_in
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: num_in
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: num_in
    type: float
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Ulet 
      MM_ROC2_eugene_dist_absent
    file: /root/nu_eigen_data/MM_ROC1_eugene_dist_present
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/eigen_data/ROC1_eigen_1-3_thresh_absent
    type: short
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: Binary Decision Path
    scale: '-1'
  states: {state: disabled}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.25'
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '-1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    comment: Threshold Range
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_1_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: customModule_eigen_calc2_0
  id: customModule_eigen_calc2
  parameters:
    Ns: '100'
    smoothing: '16'
    threshold: '60'
  states: {}
- name: customModule_eigen_calc2_0_0
  id: customModule_eigen_calc2
  parameters:
    Ns: '100'
    smoothing: '16'
    threshold: '60'
  states: {}
- name: customModule_eigen_calc2_0_1
  id: customModule_eigen_calc2
  parameters:
    Ns: '100'
    smoothing: '16'
    threshold: '60'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 2**14
    filter_source: '''Auto'''
    frequency: int(753e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.5.1
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 2**14
    filter_source: '''Auto'''
    frequency: int(753e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.4.1
  states: {}
- name: iio_pluto_source_0_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 2**14
    filter_source: '''Auto'''
    frequency: int(753e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.6.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 753e6
    fftsize: '1024'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: 2**10
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_xx_1, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_1_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '0', blocks_stream_to_vector_0_0_0_1, '0']
- [blocks_complex_to_float_0_0_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_complex_to_float_0_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_divide_xx_0, '0', blocks_divide_xx_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_divide_xx_0_1, '1']
- [blocks_divide_xx_0_1, '0', blocks_file_sink_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_threshold_ff_1, '0']
- [blocks_divide_xx_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_short_0, '0', blocks_not_xx_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_not_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', customModule_eigen_calc2_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', customModule_eigen_calc2_0_0, '0']
- [blocks_stream_to_vector_0_0_0_1, '0', customModule_eigen_calc2_0_1, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_0_0_0_0, '0', blocks_add_xx_1_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_vector_to_stream_0_0_0_0_1, '0', blocks_add_xx_1_0, '2']
- [blocks_vector_to_stream_0_1_0, '0', blocks_add_xx_1, '0']
- [blocks_vector_to_stream_0_1_0_0, '0', blocks_add_xx_1, '1']
- [blocks_vector_to_stream_0_1_0_1, '0', blocks_add_xx_1, '2']
- [customModule_eigen_calc2_0, '0', blocks_vector_to_stream_0_1_0, '0']
- [customModule_eigen_calc2_0, '1', blocks_vector_to_stream_0_0_0_0, '0']
- [customModule_eigen_calc2_0_0, '0', blocks_vector_to_stream_0_1_0_0, '0']
- [customModule_eigen_calc2_0_0, '1', blocks_vector_to_stream_0_0_0_0_0, '0']
- [customModule_eigen_calc2_0_1, '0', blocks_vector_to_stream_0_1_0_1, '0']
- [customModule_eigen_calc2_0_1, '1', blocks_vector_to_stream_0_0_0_0_1, '0']
- [iio_pluto_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [iio_pluto_source_0_0, '0', blocks_complex_to_float_0_0, '0']
- [iio_pluto_source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [iio_pluto_source_0_0_0, '0', blocks_complex_to_float_0_0_0, '0']
- [iio_pluto_source_0_0_0, '0', qtgui_freq_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
